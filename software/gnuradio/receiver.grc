options:
  parameters:
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: receiver
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    comment: total taps
    value: '8'
  states: {}
- name: LO_freq
  id: variable
  parameters:
    value: '1420405000'
  states: {}
- name: beta
  id: variable
  parameters:
    comment: beta value for kaiser
    value: '8.6'
  states: {}
- name: doppler_hz
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,4
    label: Doppler Offset [Hz]
    start: '-500000'
    step: '1000'
    stop: '500000'
    value: '0'
  states: {state: disabled}
- name: fft_size
  id: variable
  parameters:
    comment: fft size lmao
    value: '2048'
  states: {}
- name: fwhm_hz
  id: variable
  parameters:
    comment: 15 km/s FWHM at 1420 MHz = ~71.1 kHz
    value: '71100'
  states: {state: disabled}
- name: integration_time
  id: variable
  parameters:
    comment: Saved as 500 before the 2026-05-14 release, which matched no capture. The 2026-04-29 observing run used 1000 for all pointings (west, south, east at 05:02:04, and the sweep) except Dogu_100, which used 100. See observations/captures.csv.
    value: '1000'
  states: {}
- name: kaiser_window
  id: variable_low_pass_filter_taps
  parameters:
    beta: beta
    cutoff_freq: samp_rate/(4*fft_size)
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/(4*fft_size)
    win: window.WIN_KAISER
  states: {}
- name: log_dir
  id: variable
  parameters:
    value: '"logs"'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: rf bandwidth
    value: '2000000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: RX Gain [dB]
    start: '0'
    step: '1'
    stop: '73'
    value: '30'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: session_ts
  id: variable
  parameters:
    value: datetime.datetime.now().strftime("%Y%m%d_%H%M%S")
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: TX Attenuation [dB]
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '50'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: fft_size
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: fft_size*2
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: fft_size*3
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0
  id: blocks_delay
  parameters:
    delay: fft_size*4
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_0
  id: blocks_delay
  parameters:
    delay: fft_size*5
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_0_0
  id: blocks_delay
  parameters:
    delay: fft_size*6
    type: complex
  states: {}
- name: blocks_delay_0_0_1_0_0_0_0
  id: blocks_delay
  parameters:
    delay: fft_size*7
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: os.path.join(log_dir, "mergen21_spec_" + session_ts + ".dat")
    type: float
    vlen: '2048'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integration_time
    type: float
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[7*fft_size:8*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[6*fft_size:7*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[4*fft_size:5*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[0:fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[2*fft_size:3*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[5*fft_size:6*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[fft_size:2*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: kaiser_window[3*fft_size:4*fft_size]
    type: complex
    vlen: fft_size
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: (1.0/integration_time,) * fft_size
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: rf_bandwidth
    buffer_size: '32768'
    comment: TX Pluto
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: LO_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.20.1
  states: {state: disabled}
- name: import_1
  id: import
  parameters:
    imports: |
      import datetime, os
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    comment: RX Pluto
    filter_source: '''Auto'''
    frequency: LO_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.10.1
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: LO_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 6,0,2,8
    label1: RX
    name: '"RX Quick-Look FFT"'
    type: complex
    wintype: window.WIN_KAISER
    ymax: '-20'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 1,0,3,8
    label1: Power
    name: '"Integrated Power Spectrum"'
    vlen: fft_size
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/fft_size
    x_units: '"Hz"'
    y_axis_label: '"dbm/bin"'
    ymax: '-50'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 4,0,2,8
    int_max: '-70'
    int_min: '-110'
    name: '"Integrated Power waterfall"'
    type: complex
  states: {}
- name: tx_lpf
  id: low_pass_filter
  parameters:
    comment: |-
      Shapes noise to Gaussian linewidth.
      cutoff = sigma_f = FWHM/2.355
    cutoff_freq: fwhm_hz / 2.355
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: fwhm_hz / 4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: tx_noise
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    comment: Broadband Gaussian noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: tx_rotator
  id: blocks_rotator_cc
  parameters:
    comment: Doppler frequency shift
    phase_inc: 2.0 * 3.14159265 * doppler_hz / samp_rate
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_delay_0_0_1, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_0_0_1_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0_1_0_0, '0', blocks_stream_to_vector_0_0_1, '0']
- [blocks_delay_0_0_1_0_0_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_delay_0_0_1_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0_3, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_3, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0_3, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pluto_rx, '0', qtgui_freq_sink_0, '0']
- [pluto_rx, '0', qtgui_waterfall_sink_x_0, '0']
- [pluto_rx, '0', virtual_sink_0, '0']
- [tx_lpf, '0', tx_rotator, '0']
- [tx_noise, '0', tx_lpf, '0']
- [tx_rotator, '0', iio_pluto_sink_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_delay_0_0_1_0_0, '0']
- [virtual_source_0_1, '0', blocks_delay_0_0_0, '0']
- [virtual_source_0_1_0, '0', blocks_delay_0_0_1_0_0_0, '0']
- [virtual_source_0_2, '0', blocks_delay_0_0_1, '0']
- [virtual_source_0_2_0, '0', blocks_delay_0_0_1_0_0_0_0, '0']
- [virtual_source_0_3, '0', blocks_delay_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
