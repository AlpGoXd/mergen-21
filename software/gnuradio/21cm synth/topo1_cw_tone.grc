options:
  parameters:
    author: Mergen-21
    comment: |-
      Topology 1: Single CW tone
      TX Pluto: 192.168.20.1
      RX Pluto: 192.168.10.1
      CW at +100 kHz offset from H-line center.
      Use for gain cal and freq accuracy check.
    description: 'Topo 1: CW tone at H-line'
    generate_options: qt_gui
    id: topo1_cw_tone
    output_language: python
    title: 'Topo 1: CW Tone'
  states: {}

blocks:
- name: LO_freq
  id: variable
  parameters:
    comment: H-line rest frequency
    value: '1420405000'
  states: {}
- name: cw_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,4
    label: CW Offset [Hz]
    start: '-1500000'
    step: '1000'
    stop: '1500000'
    value: '100000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: 4096 -> 752 Hz/bin = 0.16 km/s
    value: '4096'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: Match to sample rate
    value: '3080000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: RX Gain [dB]
    start: '0'
    step: '1'
    stop: '73'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3080000'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: TX Attenuation [dB]
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '50'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    comment: Average 1000 spectra
    decim: '100'
    type: float
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '4096'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: rf_bandwidth
    buffer_size: '32768'
    comment: TX Pluto
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: LO_freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.20.1
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    comment: RX Pluto
    filter_source: '''Auto'''
    frequency: LO_freq
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.20.1
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    comment: Quick-look FFT (built-in)
    fc: LO_freq
    fftsize: fft_size
    grid: 'True'
    gui_hint: 4,0,2,4
    label1: RX
    name: '"RX Quick-Look FFT"'
    type: complex
    ymax: '-20'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    comment: Displays integrated PSD directly
    grid: 'True'
    gui_hint: 2,0,2,4
    label1: Power
    name: '"Received Power Spectrum"'
    vlen: fft_size
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/fft_size
    x_units: '"Hz"'
    y_axis_label: '"Power"'
    ymax: '1'
    ymin: '0'
  states: {}
- name: tx_signal
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: CW tone at adjustable offset
    freq: cw_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pluto_rx, '0', blocks_stream_to_vector_0, '0']
- [tx_signal, '0', iio_pluto_sink_0, '0']
- [tx_signal, '0', qtgui_freq_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
